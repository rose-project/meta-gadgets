require kodi.inc

BRANCH = "Jarvis"
SRCREV="a6d8b948448985d8ab27e96d66e1214a855e50f5"

PR = "${INC_PR}"
