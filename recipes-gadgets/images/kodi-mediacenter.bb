require recipes-rose/images/rose-image-multimedia.bb

DESCRIPTION = "Kodi Mediacenter Image"

IMAGE_INSTALL += " \
    "

